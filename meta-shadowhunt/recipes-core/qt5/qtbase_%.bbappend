PACKAGECONFIG_append = " fontconfig "
PACKAGECONFIG_remove = " gtkstyle "
