PACKAGECONFIG_append = " gstreamer "
