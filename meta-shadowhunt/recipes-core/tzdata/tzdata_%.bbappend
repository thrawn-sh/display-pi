# Europe/Paris is same timezone as Europe/Berlin
DEFAULT_TIMEZONE = "Europe/Paris"
