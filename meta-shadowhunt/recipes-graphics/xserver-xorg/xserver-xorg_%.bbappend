PACKAGECONFIG_append = " glx "
